# Autodesk Inventor part: ESP32WROOM32D4MBPS
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2021-12
Part Number: ESP32WROOM32D4MBPS
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: ESP32WROOM32D4MBPS
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
