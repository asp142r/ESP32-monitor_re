# Autodesk Inventor part: 2X20
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2021-12
Part Number: 2X20
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: 2X20
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
