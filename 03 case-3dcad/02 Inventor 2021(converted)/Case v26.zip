# Autodesk Inventor part: C1206
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2021-12
Part Number: C1206
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: C1206
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
